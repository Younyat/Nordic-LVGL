## build/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "C:/Users/Administrador/ncs/v1.8.0/nrf/boards/shields/*/Kconfig.defconfig"
```
